# IAR project Template.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; RAM_VECTOR
  ICC430.newCCIncludePaths: $PROJ_DIR$; Drivers\inc; Drivers\src; HardWare; HardWare\led; HardWare\key; HardWare\lcd; HardWare\lcd_api; HardWare\nrf24l01; HardWare\oled; HardWare\delay; HardWare\2.2TFT; System; System\inc; System\src; User; User\USER
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  ICC430.CCDefines: NDEBUG; RAM_VECTOR
  ICC430.newCCIncludePaths: $PROJ_DIR$; Drivers\inc; Drivers\src; HardWare; HardWare\led; HardWare\key; HardWare\lcd; HardWare\lcd_api; HardWare\nrf24l01; HardWare\oled; HardWare\delay; HardWare\2.2TFT; System; System\inc; System\src; User; User\USER; D:\Dev\Project\TI_Car\HardWare\motor; D:\Dev\Project\TI_Car\User; D:\Dev\Project\TI_Car\HardWare\encoder
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  group HardWare
    HardWare/delay/: delay.c delay.h
    HardWare/encoder/: encoder.c encoder.h
    HardWare/KEY/: KEY.c KEY.h
    HardWare/2.2TFT/: LCD.c LCD.h
    HardWare/LCD_API/: LCD_API.c LCD_API.h LCD_FONT.c LCD_FONT.H
    HardWare/LED/: LED.c LED.h
    HardWare/motor/: motor.c motor.h
    HardWare/nrf24l01/: nrf2401.c nrf2401.h
    HardWare/oled/: OLED.c OLED.h
    HardWare/remote/: remote.c remote.h
  group StdPeriph_Driver
    Drivers/src/: msp430f5529_adc.c msp430f5529_clock.c msp430f5529_compater.c msp430f5529_dma.c msp430f5529_flash.c msp430f5529_gpio.c msp430f5529_i2c.c msp430f5529_lpm.c msp430f5529_nmi.c msp430f5529_remap.c msp430f5529_rtc.c msp430f5529_spi.c msp430f5529_timer.c msp430f5529_uart.c msp430f5529_watchdog.c
    Drivers/inc/: msp430f5529_adc.h msp430f5529_clock.h msp430f5529_compater.h msp430f5529_dma.h msp430f5529_flash.h msp430f5529_gpio.h msp430f5529_i2c.h msp430f5529_lpm.h msp430f5529_nmi.h msp430f5529_remap.h msp430f5529_rtc.h msp430f5529_spi.h msp430f5529_timer.h msp430f5529_uart.h msp430f5529_watchdog.h
    System/src/: msp430f5529_vectors.c
    System/inc/: msp430f5529_vectors.h
  group System
    System/src/: assert.c startup_msp430f5529.c
    System/inc/: common.h include.h msp430f5529_system.h
  group User
    User/: app_main.c app_main.h main.c
    System/src/: msp430f5529_it.c
  group User/User
    User/USER/: PID.c PID.h
